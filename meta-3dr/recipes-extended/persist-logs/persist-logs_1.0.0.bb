LICENSE = "CLOSED"

ALLOW_EMPTY_${PN} = "1"

DEPENDS_${PN} = " \
    busybox \
    initscripts \
    logrotate \
    sysvinit \
    wtmp-rotate \
    "

RDEPENDS_${PN} = " \
    busybox \
    initscripts \
    logrotate \
    sysvinit \
    wtmp-rotate \
    "
